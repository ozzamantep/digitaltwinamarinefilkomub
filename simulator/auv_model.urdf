Commit message: Update AUV mass configuration to 22.5 kg

File: simulator/auv_model.urdf (robot description, URDF)
Before this commit: robot custom_auv_bluerov2, 10 links, 9 joints
Links:
- link base_link: mass 11.5 -> 22.5
